# IAR project Backup of lib_lpc_chip_540xx.ewp, settings and files
configuration chip_540xx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: adc_540xx.c chip_540xx.c clock_540xx.c cpuctrl_540xx.c crc_540xx.c ctimer_540xx.c dma_540xx.c gpio_540xx.c gpiogroup_540xx.c i2c_common_540xx.c i2cm_540xx.c i2cs_540xx.c iocon_540xx.c ostimer_540xx.c pinint_540xx.c rtc_540xx.c sct_540xx.c sct_pwm_540xx.c spi_540xx.c spi_common_540xx.c spim_540xx.c spis_540xx.c stopwatch_540xx.c syscon_540xx.c sysinit_540xx.c uart_540xx.c utick_540xx.c vfifo_540xx.c wwdt_540xx.c
    ../chip_common/: fpu_init.c iap.c ring_buffer.c
  group libs
    pmu_library/iar/: pmu_library.a
