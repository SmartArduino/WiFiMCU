# Keil uVision project lib_lpc_chip_540xx.uvproj, settings and files
target chip_540xx_lib (ARM-ADS)
  device: ARMCM4 ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: chip_540xx_lib (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: .\config;..\chip_540xx;..\chip_common;..\..\..\CMSIS\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group csp
    ../chip_common/: ring_buffer.c fpu_init.c iap.c
    ./: chip_540xx.c clock_540xx.c crc_540xx.c gpio_540xx.c iocon_540xx.c pinint_540xx.c sct_540xx.c sct_pwm_540xx.c spi_common_540xx.c spi_540xx.c spim_540xx.c syscon_540xx.c sysinit_540xx.c adc_540xx.c cpuctrl_540xx.c ctimer_540xx.c dma_540xx.c ostimer_540xx.c vfifo_540xx.c utick_540xx.c wwdt_540xx.c uart_540xx.c rtc_540xx.c i2cm_540xx.c i2c_common_540xx.c i2cs_540xx.c gpiogroup_540xx.c spis_540xx.c stopwatch_540xx.c
  group lib
    ./pmu_library/keil/: pmu_library.lib
