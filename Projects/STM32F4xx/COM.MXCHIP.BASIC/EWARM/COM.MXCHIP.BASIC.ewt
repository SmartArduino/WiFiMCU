<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3165</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.BASIC\main.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3165</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3165\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3165\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3165\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff_gen_drv.c</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\sd_diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\sdram_diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\sram_diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\usbh_diskio.c</name>
        </file>
      </group>
      <group>
        <name>Options</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\syscall.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\unicode.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>GladmanAES</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aes_modes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aescrypt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aeskey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aestab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\gf128mul.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\Library\mxchipWNet_cm4f_8801.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\Library\mxchipWNet_cm4f_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\Library\RF driver\wlan_firmware.c</name>
    </file>
  </group>
  <group>
    <name>lua</name>
    <group>
      <name>exlibs</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\file.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\lexlibs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\mcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\net.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\user_version.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lua\exlibs\wifi.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\compiler.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lapi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lapi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lauxlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lauxlib.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lbaselib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lcode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lcode.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldblib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldebug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldebug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldo.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ldump.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\legc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\legc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lfunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lgc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lgc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\linit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\liolib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\llex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\llex.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\llimits.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lmathlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lmem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lmem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\loadlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lobject.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lobject.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lopcodes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lopcodes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\loslib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lparser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lparser.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lrodefs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lrotable.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lrotable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lstate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lstate.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lstring.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lstring.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lstrlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ltable.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ltable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ltablib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ltm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\ltm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lua.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lua.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\luaconf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lualib.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lundump.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lundump.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lvm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lvm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lzio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lua\lzio.h</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOCli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONotificationCenter.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOSystemMonitor.h</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MicoDriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <group>
          <name>sensors</name>
          <group>
            <name>dc_motor</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\dc_motor\dc_motor.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\dc_motor\dc_motor.h</name>
            </file>
          </group>
          <group>
            <name>infrared_reflective</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\infrared_reflective\infrared_reflective.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\infrared_reflective\infrared_reflective.h</name>
            </file>
          </group>
          <group>
            <name>key</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\key\keys.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\key\keys.h</name>
            </file>
          </group>
          <group>
            <name>lcd</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\lcd\AsciiLib.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\lcd\AsciiLib.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\lcd\oled.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\lcd\oled.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\lcd\oledfont.h</name>
            </file>
          </group>
          <group>
            <name>light</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\light\light_sensor.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\light\light_sensor.h</name>
            </file>
          </group>
          <group>
            <name>rgb_led</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\rgb_led\hsb2rgb_led.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\rgb_led\hsb2rgb_led.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\rgb_led\rgb_led.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\rgb_led\rgb_led.h</name>
            </file>
          </group>
          <group>
            <name>temp_hum_sensor</name>
            <group>
              <name>BME280</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\BME280\bme280.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\BME280\bme280.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\BME280\bme280_user.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\BME280\bme280_user.h</name>
              </file>
            </group>
            <group>
              <name>DHT11</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\DHT11\DHT11.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\DHT11\DHT11.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\temp_hum_sensor.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor\temp_hum_sensor.h</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx</name>
      <group>
        <name>EWARM</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\EWARM\startup_stm32f411xe_IAR.s</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <group>
          <name>Libraries</name>
          <group>
            <name>STM32F4xx_StdPeriph_Driver</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\paltform_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_mcu_powersave.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_rng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_watchdog.c</name>
        </file>
      </group>
      <group>
        <name>Wi-Fi_Bus_Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\read_wifi_firmware.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_sdio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_platform.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\platform_init.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
    </file>
  </group>
  <group>
    <name>spiffs</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_cache.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_check.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_gc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_hydrogen.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_nucleus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\spiffs\spiffs_nucleus.h</name>
    </file>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\URLUtils.c</name>
    </file>
  </group>
  <group>
    <name>USB</name>
    <group>
      <name>usb_cdc_device</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_dcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_dcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_dcd_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_dcd_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_defines.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usb_regs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_cdc_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_cdc_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_cdc_vcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_cdc_vcp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_desc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_ioreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_ioreq.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_req.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_req.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_usr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\USB\usb_cdc_device\usbd_usr.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\USB\tm_stm32f4_usb_vcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\USB\tm_stm32f4_usb_vcp.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\README.md</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\readme.txt</name>
  </file>
</project>


